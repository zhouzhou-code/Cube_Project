# Keil uVision project task_FreeRTOS_advanced_c8t6.uvprojx, settings and files
target task_FreeRTOS_advanced_c8t6 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: task_FreeRTOS_advanced_c8t6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\task_FreeRTOS_advanced_c8t6_myBSP\driver_Hardware;..\task_FreeRTOS_advanced_c8t6_myBSP\driver_Hardware\MPU6050;..\task_FreeRTOS_advanced_c8t6_myBSP\driver_Hardware\MPU6050\eMPL;..\task_FreeRTOS_advanced_c8t6_myBSP\Public;..\task_FreeRTOS_advanced_c8t6_myBSP\Public\SYSTEM;..\task_FreeRTOS_advanced_c8t6_myBSP\Public\SYSTEM\sys;..\task_FreeRTOS_advanced_c8t6_myBSP\driver_Hardware\OLED
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group public
    ../task_FreeRTOS_advanced_c8t6_myBSP/Public/: delay.c interrupt_callbacks.c
    ../task_FreeRTOS_advanced_c8t6_myBSP/Public/SYSTEM/sys/: sys.c
  group hardware_driver
    ../task_FreeRTOS_advanced_c8t6_myBSP/driver_Hardware/OLED/: OLED.c
    ../task_FreeRTOS_advanced_c8t6_myBSP/driver_Hardware/MPU6050/: mpu6050.c mpuiic.c
    ../task_FreeRTOS_advanced_c8t6_myBSP/driver_Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 4.3.0
